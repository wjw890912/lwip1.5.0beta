# Keil uVision project LWIP150_GIT.uvproj, settings and files
target lwip_git (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: LWIP150_GIT +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL,
  c include: ..\myself\inc;..\Libraries\CMSIS\Core\CM3;..\Libraries\STM32_ETH_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\lwip\src\include;..\lwip\src\include\lwip;..\lwip\src\include\netif;..\lwip\src\include\posix;..\lwip\test\unit;..\lwip\archport;..\lwip\archport\port;..\lwip\src\include\netif\ppp;..\lwip;..\myself\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../myself/src/: main.c stm32f10x_it.c stm32f107.c netconf.c
  group chip_dev_lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group eth_dev
    ../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group lwip_core
    ../lwip/src/core/: def.c dns.c inet_chksum.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../lwip/src/core/ipv4/: autoip.c dhcp.c icmp.c igmp.c ip4.c ip4_addr.c ip_frag.c
  group lwip_api
    ../lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
  group lwip_netif
    ../lwip/src/netif/: etharp.c
  group lwip_port
    ../lwip/archport/port/: ethernetif.c
  group cpu
    ../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
  group readme
    ./: LWIP1.5.0 @qq925295580.txt
